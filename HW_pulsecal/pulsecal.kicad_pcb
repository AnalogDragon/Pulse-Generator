# Repository AnalogDragon/Pulse-Generator

File README.md:

**Pulse Generator**  
  
[中文](./README-zh.md)  

Used for testing and calibrating dose rate instruments such as survey meters or calibrators. STM32G0, KiCad.  
  
This device was built because I purchased a LUDLUM Model 3 and a Model 2360, both of which require calibration of multiple threshold levels, so I made this small tool for that purpose.  
  
Functions:  
- 1. Generates adjustable pulses with amplitude 2 mV–1000 mV, pulse width 50 nS–500 µS, adjustable frequency, and selectable positive/negative polarity, for calibration or performance verification;  
- 2. Multiple operating modes;  
- 3. Output interface changed to MHV connector (previous low-quality BNC connectors could suffer dielectric breakdown);  
- 4. Supports USB power supply and battery power; when USB is connected, the battery is automatically disconnected;  

## Buttons  

**Button function description**  

- A: **Increment** button. When a digit is selected, pressing it increases the value by +1;  
- B: **Select / Mode** button. **Short press** switches the selected digit position; **long press** switches the **mode** (see [Modes](#modes));  
- C: **Decrement** button. When a digit is selected, pressing it decreases the value by −1;  
- D: **Pulse Width** button. Short press to set, long press to change the multiplier. Range: 500 µS–50 nS, minimum step 50 nS, 4 significant digits;  
- E: **Frequency** button. Short press to set, long press to change the multiplier. Range: 5 MHz–0.1 Hz, 3 or 4 significant digits;  
- F: **Voltage** button. Short press to set, long press to switch between **output pulse voltage** and **input high-voltage value**;  
- G: **Output** button. Press to start outputting the configured pulses;  

***Other operations***  
- A + B: Switch output pulse polarity to **positive polarity** pulses (display shows `POS_┌┐_`)  
- C + B: Switch output pulse polarity to **negative polarity** pulses (display shows `NEG‾└┘‾`)  

***High-voltage calibration***  
How to enter: during power-on, hold F + B to enter calibration mode.  

Single-point calibration by default. You can press D / E / F to switch the number of calibration points to 1 / 3 / 5 (updated in V1.2).  
During calibration, adjust the displayed voltage to match the input voltage. Keep the voltage unchanged, then long-press the **Output** button (G) to save the calibration point.  
After the required number of calibration points is saved, calibration ends automatically. If the result displays `DONE`, calibration is successful. If `FAILED RETRY` is displayed, calibration has failed.  

Possible reasons for calibration failure:  
- The voltage difference between calibration points is less than 100 V (for example, point 1 is 100 V and point 2 is 150 V);  
- No input voltage during calibration;  
- The input voltage is not correlated with the displayed voltage;  

## Modes  

Three modes are supported:  

- Normal mode (`NORMAL MODE`): the configured parameters output **continuous** pulses. During output, a rapidly blinking indicator appears at the lower-right corner of the display to show status;  
- Repeat burst mode (`REPEAT BURST`): the configured parameters are output at **100 CPS**;  
- Single burst mode (`SINGEL BURST`): with the configured parameters, each press of the **Output** button generates exactly **100 pulses**;  

## Schematic  

[Schematic](./SCH.pdf)  

## Hardware  

## TEST  
- Normal mode set 1.67CPS(100KCPM)  

- Repeat burst mode (6KCPM)

## KiCad design HW_pulsecal/pulsecal.kicad_pcb

Parts:
C1: 10nF/4kV; C_Rect_L13.5mm_W4.0mm_P10.00mm_FKS3_FKP3_MKS4
C2, C4, C5, C8, C18, C19, C24: 105/25V; C_0402_1005Metric
C3, C22, C23, C25: 104/50V; C_0402_1005Metric
C7: 106/16V; C_0603_1608Metric
C20, C21: 101/50V; C_0402_1005Metric
C30, C31: 103/50V; C_0402_1005Metric
D1: SMBJ3.3A; D_SMB
FB1: 600R/100M; L_0603_1608Metric
J1: MHV-KE; BNC_TEConnectivity_1478204_Vertical
J4: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
Q3: FDG6301N; SOT-363_SC-70-6
R1: 100R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R2, R3: 500M; R_1206_3216Metric
R4: 1M; R_0603_1608Metric
R5, R6, R15: 10K; R_0402_1005Metric
R7, R8, R9, R14, R37: 100R; R_0402_1005Metric
R10, R12: 1R; R_0402_1005Metric
R11: 22K; R_0402_1005Metric
U1, U2: TLV9061IDBVR; SOT-23-5
U5: STM32G030C8Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C4.1, C5.1, C23.2, C24.2, FB1.1, J4.1, U1.5 (V+), U2.5 (V+), U5.4 (VBAT), U5.6 (VDD); also elsewhere on the board
-2V5: C18.1, C19.1, U1.2 (V-), U2.2 (V-); also elsewhere on the board
/dac: C7.2, C8.2, R11.1, R15.2, U2.3 (+)
DISP_A: U5.30 (PC6); also elsewhere on the board
DISP_B: U5.34 (PA12/PA10); also elsewhere on the board
DISP_C: U5.23 (PB11); also elsewhere on the board
DISP_D: U5.21 (PB2); also elsewhere on the board
DISP_DIG1: U5.27 (PB15); also elsewhere on the board
DISP_DIG2: U5.22 (PB10); also elsewhere on the board
DISP_DIG3: U5.32 (PA10/NC); also elsewhere on the board
DISP_DIG4: U5.38 (PD0); also elsewhere on the board
DISP_DIG5: U5.40 (PD2); also elsewhere on the board
DISP_DIG6: U5.44 (PB5); also elsewhere on the board
DISP_DP: U5.29 (PA9/NC); also elsewhere on the board
DISP_E: U5.31 (PC7); also elsewhere on the board
DISP_F: U5.20 (PB1); also elsewhere on the board
DISP_G1: U5.43 (PB4); also elsewhere on the board
DISP_G2: U5.41 (PD3); also elsewhere on the board
DISP_H: U5.26 (PB14); also elsewhere on the board
DISP_J: U5.24 (PB12); also elsewhere on the board
DISP_K: U5.42 (PB3); also elsewhere on the board
DISP_L: U5.39 (PD1); also elsewhere on the board
DISP_M: U5.37 (PA15); also elsewhere on the board
DISP_N: U5.33 (PA11/PA9); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C7.1, C8.1, C18.2, C19.2, C22.1, C23.1, C24.1, C25.1, C30.1, C31.1, D1.2 (A), J1.2 (Ext), J4.3, R4.2, R12.1, R15.1, R37.2, U5.7 (VSS); also elsewhere on the board
HV_ADC: C30.2, R7.2, U5.12 (PA1)
unnamed: C1.2, R1.1
unnamed: D1.1 (K), Q3.1 (S), Q3.3 (D), R1.2
unnamed: C1.1, J1.1 (In), R2.1
unnamed: C2.1, Q3.6 (D), R10.1, R37.1
unnamed: C20.2, Q3.2 (G), R8.1
unnamed: C21.2, Q3.5 (G), R9.1
unnamed: Q3.4 (S), R12.2
unnamed: R2.2, R3.1
unnamed: R5.2, R7.1, U1.1
unnamed: R6.1, R10.2, R14.1, U2.1
unnamed: C3.1, R3.2, R4.1, U1.3 (+)
unnamed: R5.1, U1.4 (-)
unnamed: R6.2, U2.4 (-)
unnamed: C22.2, U5.10 (NRST)
SWCLK: J4.4, U5.36 (PA14)
SWDIO: J4.2, U5.35 (PA13)
VAA: C25.2, FB1.2, U5.5 (VREF+)
bat_adc: U5.11 (PA0); also elsewhere on the board
dac_fb: C31.2, R14.2, U5.13 (PA2)
dac_pwm: R11.2, U5.17 (PA6)
key_add: U5.3 (PC15); also elsewhere on the board
key_freq: U5.48 (PB9); also elsewhere on the board
key_move: U5.47 (PB8); also elsewhere on the board
key_output: U5.1 (PC13); also elsewhere on the board
key_pulse: U5.2 (PC14); also elsewhere on the board
key_sub: U5.45 (PB6); also elsewhere on the board
key_volt: U5.46 (PB7); also elsewhere on the board
pulse: C20.1, R8.2, U5.28 (PA8)
pulse_n: C21.1, R9.2, U5.25 (PB13)

Notes on the sheet:
0.6uA max
CH1N CH1
1000:1

Parts:
C6, C9: 475/10V; C_0603_1608Metric
C10, C12, C14, C26, C27: 106/16V; C_0603_1608Metric
C11, C13, C15, C17, C28, C29: 104/50V; C_0402_1005Metric
C16: 226/6.3V; C_0603_1608Metric
D2: 1N4007; D_SOD-323_HandSoldering
D5: B5819W; D_SOD-123
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: Conn_01x02; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
Q1: AO3401A; SOT-23
R31: 1K; R_0402_1005Metric
R32, R36: 200K; R_0402_1005Metric
R33: 10K; R_0402_1005Metric
R34, R35: 5.1K; R_0402_1005Metric
U3: SGM3204; SOT-23-6
U4: TX4310B; SOT-23-6

Connections:
+2V5: C10.1, C11.1, D2.1 (K), U3.2 (IN), U3.5 (EN)
+3V3: C16.1, C17.1, D2.2 (A), U4.1 (Vout); also elsewhere on the board
+5V: C27.1, D5.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R31.2
+BATT: C26.1, J3.1, Q1.3 (D), R32.2
-2V5: C12.2, C13.2, U3.1 (OUT); also elsewhere on the board
GND: C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C26.2, C27.2, C28.2, C29.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.2, J3.MP (MountPin), R33.1, R34.1, R35.1, R36.1, U3.4 (GND), U4.2 (GND); also elsewhere on the board
unnamed: J2.A5 (CC1), R34.2
unnamed: J2.B5 (CC2), R35.2
unnamed: C28.1, Q1.1 (G), R31.1, R33.2
unnamed: C6.2, U3.3 (C_{N})
unnamed: C6.1, U3.6 (C_{P})
unnamed: C9.1, U4.6 (C+)
unnamed: C9.2, U4.4 (C-)
VBUS: C14.1, C15.1, D5.1 (K), Q1.2 (S), U4.3 (EN), U4.5 (VIN)
bat_adc: C29.1, R32.1, R36.2; also elsewhere on the board

Notes on the sheet:
PORT
负压产生

Parts:
D3: display-led-0.39in-6dig
R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30: 330R; R_0402_1005Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7: 6*6*5 100g; SW_SPST_PTS645

Connections:
DISP_A: R16.1; also elsewhere on the board
DISP_B: R17.1; also elsewhere on the board
DISP_C: R18.1; also elsewhere on the board
DISP_D: R19.1; also elsewhere on the board
DISP_DIG1: D3.2 (DIG1); also elsewhere on the board
DISP_DIG2: D3.20 (DIG2); also elsewhere on the board
DISP_DIG3: D3.17 (DIG3); also elsewhere on the board
DISP_DIG4: D3.15 (DIG4); also elsewhere on the board
DISP_DIG5: D3.14 (DIG5); also elsewhere on the board
DISP_DIG6: D3.12 (DIG6); also elsewhere on the board
DISP_DP: R30.1; also elsewhere on the board
DISP_E: R20.1; also elsewhere on the board
DISP_F: R21.1; also elsewhere on the board
DISP_G1: R22.1; also elsewhere on the board
DISP_G2: R23.1; also elsewhere on the board
DISP_H: R24.1; also elsewhere on the board
DISP_J: R25.1; also elsewhere on the board
DISP_K: R26.1; also elsewhere on the board
DISP_L: R27.1; also elsewhere on the board
DISP_M: R28.1; also elsewhere on the board
DISP_N: R29.1; also elsewhere on the board
GND: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2; also elsewhere on the board
unnamed: D3.18 (A), R16.2
unnamed: D3.16 (B), R17.2
unnamed: D3.3 (C), R18.2
unnamed: D3.4 (D), R19.2
unnamed: D3.5 (DP), R30.2
unnamed: D3.6 (E), R20.2
unnamed: D3.19 (F), R21.2
unnamed: D3.11 (G1), R22.2
unnamed: D3.10 (G2), R23.2
unnamed: D3.22 (H), R24.2
unnamed: D3.21 (J), R25.2
unnamed: D3.13 (K), R26.2
unnamed: D3.9 (L), R27.2
unnamed: D3.8 (M), R28.2
unnamed: D3.7 (N), R29.2
key_add: SW5.1; also elsewhere on the board
key_freq: SW2.1; also elsewhere on the board
key_move: SW6.1; also elsewhere on the board
key_output: SW4.1; also elsewhere on the board
key_pulse: SW1.1; also elsewhere on the board
key_sub: SW7.1; also elsewhere on the board
key_volt: SW3.1; also elsewhere on the board

Notes on the sheet:
output
freq
50~9999
volt
0.1~5000000
5~1000
Hz/KHz/MHz
pulse
move

Board: 2 copper layers, 98.0 x 98.0 mm, 90 parts (0 on the bottom side), 81 nets.

## Code that names these connections

File SW_PulseGenerator/PulseGenerator.ioc (part):

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Mcu.Name=STM32G030C(6-8)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32G030C6Tx
PA0.Mode=IN0
PA0.Signal=ADC1_IN0
PA1.Mode=IN1
PA1.Signal=ADC1_IN1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DISP_DIG3
PA10.Signal=GPIO_Output
PA11\ [PA9].GPIOParameters=PinState,GPIO_Label
PA11\ [PA9].GPIO_Label=DISP_N
PA11\ [PA9].PinState=GPIO_PIN_SET
PA11\ [PA9].Signal=GPIO_Output
PA12\ [PA10].GPIOParameters=PinState,GPIO_Label
PA12\ [PA10].GPIO_Label=DISP_B
PA12\ [PA10].PinState=GPIO_PIN_SET
PA12\ [PA10].Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=SYS_SWCLK
PA15.GPIOParameters=PinState,GPIO_Label
PA15.GPIO_Label=DISP_M
PA15.PinState=GPIO_PIN_SET
PA15.Signal=GPIO_Output
PA2.Mode=IN2
PA2.Signal=ADC1_IN2
PA6.GPIOParameters=GPIO_PuPd
PA6.GPIO_PuPd=GPIO_NOPULL
PA6.Signal=S_TIM16_CH1
PA8.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd
PA8.GPIO_PuPd=GPIO_PULLDOWN
PA8.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA8.PinState=GPIO_PIN_RESET
PA8.Signal=S_TIM1_CH1
PA9.GPIOParameters=PinState,GPIO_Label
PA9.GPIO_Label=DISP_DP
PA9.PinState=GPIO_PIN_SET
PA9.Signal=GPIO_Output
PB1.GPIOParameters=PinState,GPIO_Label
PB1.GPIO_Label=DISP_F
PB1.PinState=GPIO_PIN_SET
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=DISP_DIG2
PB10.Signal=GPIO_Output
PB11.GPIOParameters=PinState,GPIO_Label
PB11.GPIO_Label=DISP_C
PB11.PinState=GPIO_PIN_SET
PB11.Signal=GPIO_Output
PB12.GPIOParameters=PinState,GPIO_Label
PB12.GPIO_Label=DISP_J
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd
PB13.GPIO_PuPd=GPIO_PULLUP
PB13.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.PinState=GPIO_PIN_SET
PB13.Signal=TIM1_CH1N
PB14.GPIOParameters=PinState,GPIO_Label
PB14.GPIO_Label=DISP_H
PB14.PinState=GPIO_PIN_SET
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=DISP_DIG1
PB15.Signal=GPIO_Output
PB2.GPIOParameters=PinState,GPIO_Label
PB2.GPIO_Label=DISP_D
PB2.PinState=GPIO_PIN_SET
PB2.Signal=GPIO_Output
PB3.GPIOParameters=PinState,GPIO_Label
PB3.GPIO_Label=DISP_K
PB3.PinState=GPIO_PIN_SET
PB3.Signal=GPIO_Output
PB4.GPIOParameters=PinState,GPIO_Label
PB4.GPIO_Label=DISP_G1
PB4.PinState=GPIO_PIN_SET
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=DISP_DIG6
PB5.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_PuPd,GPIO_Label
PB6.GPIO_Label=key_sub
PB6.GPIO_PuPd=GPIO_PULLUP
PB6.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_PuPd,GPIO_Label
PB7.GPIO_Label=key_volt
PB7.GPIO_PuPd=GPIO_PULLUP
PB7.Signal=GPIO_Input
PB8.GPIOParameters=GPIO_PuPd,GPIO_Label
PB8.GPIO_Label=key_move
PB8.GPIO_PuPd=GPIO_PULLUP
PB8.Signal=GPIO_Input
PB9.GPIOParameters=GPIO_PuPd,GPIO_Label
PB9.GPIO_Label=key_freq
PB9.GPIO_PuPd=GPIO_PULLUP
PB9.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_PuPd,GPIO_Label
PC13.GPIO_Label=key_output
PC13.GPIO_PuPd=GPIO_PULLUP
PC13.Signal=GPIO_Input
PC14-OSC32_IN\ (PC14).GPIOParameters=GPIO_PuPd,GPIO_Label
PC14-OSC32_IN\ (PC14).GPIO_Label=key_pulse
PC14-OSC32_IN\ (PC14).GPIO_PuPd=GPIO_PULLUP
PC14-OSC32_IN\ (PC14).Signal=GPIO_Input
PC15-OSC32_OUT\ (PC15).GPIOParameters=GPIO_PuPd,GPIO_Label
PC15-OSC32_OUT\ (PC15).GPIO_Label=key_add
PC15-OSC32_OUT\ (PC15).GPIO_PuPd=GPIO_PULLUP
PC15-OSC32_OUT\ (PC15).Signal=GPIO_Input
PC6.GPIOParameters=PinState,GPIO_Label
PC6.GPIO_Label=DISP_A
PC6.PinState=GPIO_PIN_SET
PC6.Signal=GPIO_Output
PC7.GPIOParameters=PinState,GPIO_Label
PC7.GPIO_Label=DISP_E
PC7.PinState=GPIO_PIN_SET
PC7.Signal=GPIO_Output
PD0.GPIOParameters=GPIO_Label
PD0.GPIO_Label=DISP_DIG4
PD0.Signal=GPIO_Output
PD1.GPIOParameters=PinState,GPIO_Label
PD1.GPIO_Label=DISP_L
PD1.PinState=GPIO_PIN_SET
PD1.Signal=GPIO_Output
PD2.GPIOParameters=PinState,GPIO_Label
PD2.GPIO_Label=DISP_DIG5
PD2.PinState=GPIO_PIN_RESET
PD2.Signal=GPIO_Output
PD3.GPIOParameters=PinState,GPIO_Label
PD3.GPIO_Label=DISP_G2
PD3.PinState=GPIO_PIN_SET
PD3.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=60000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2025-06-01 rename
2025-06-11 Update main.c
    dac范围改为0-3.2V
2025-06-12 update
    增加设置数字位数和清初末尾数字
2025-06-14 md update
2025-06-19 update md
2025-10-27 更新
    增加了一个电阻，可以极大的减少低压输出的振铃
2025-10-27 update
    范围改成2mV-999mV
2025-10-28 update v1.2
    改连接器，改贴片器件为直插器件
2025-10-29 UPDATE
    改连接器和输入电路
2025-11-04 update
    增加了多点校准，
2025-11-05 update
    增加了开机显示version，增加了3d打印的文件
2026-03-01 add img
2026-03-01 Rename IMG100CPS.JPG to IMG100CPS.jpg
2026-03-01 Rename IMG100KPM.JPG to IMG100KPM.jpg
